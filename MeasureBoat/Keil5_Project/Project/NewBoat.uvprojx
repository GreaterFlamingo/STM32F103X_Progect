# Keil uVision project NewBoat.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NewBoat +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CMSI;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\USER\CODE
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMSI
    ../CMSI/: core_cm3.c system_stm32f10x.c
    ../CMSI/startup/arm/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_dma.c
  group USER
    ../USER/: main.c stm32f10x_it.c
  group CODE
    ../USER/CODE/: Delay.c KEY.c Measure.c PWM.c MOTO.c NVIC.c USART1.c USART2.c MODE.c ADC.c TIME3.c Test.c
